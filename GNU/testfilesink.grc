options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: FileSourceSyntax
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/josh/Documents/SD/21-29-Starobike/GNU/test_file_sink.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/josh/Documents/SD/21-29-Starobike/GNU/received.txt
    repeat: 'True'
    type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
