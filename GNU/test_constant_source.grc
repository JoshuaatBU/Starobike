options:
  parameters:
    author: josh
    generate_options: qt_gui
    id: tb
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '23'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '100'
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
