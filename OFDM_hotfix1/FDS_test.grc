options:
  parameters:
    author: jshall
    generate_options: no_gui
    id: FDS_test
    output_language: python
    run_options: run
    title: FDS_test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/jshall/Projects/21-29-Starobike/OFDM_hotfix1/OFDM_test.txt
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jshall/Projects/21-29-Starobike/testing_scripts/bike_gps_data.txt
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
