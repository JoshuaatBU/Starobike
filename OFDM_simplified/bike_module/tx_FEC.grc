options:
  parameters:
    author: jshall
    category: Custom
    description: OFDM Transmitter
    generate_options: no_gui
    id: OFDM_FEC_TX
    output_language: python
    run_options: run
    title: OFDM_FEC_TX
  states: {}

blocks:
- name: cent_freq
  id: variable
  parameters:
    value: '123456'
  states: {}
- name: def1
  id: variable_polar_encoder_def
  parameters:
    block_size: '512'
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    is_packed: 'False'
    ndim: '0'
    num_info_bits: '240'
  states: {}
- name: def2
  id: variable_polar_encoder_def
  parameters:
    block_size: '512'
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    is_packed: 'False'
    ndim: '0'
    num_info_bits: '240'
  states: {state: disabled}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '37'
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: polar_config
  id: variable_polar_code_configurator
  parameters:
    block_size: '512'
    channel: polar.CHANNEL_TYPE_BEC
    design_snr: '0.0'
    mu: '32'
    num_info_bits: '240'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jshall/Projects/21-29-Starobike/OFDM_simplified/car_module/recieved.bin
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'False'
    ipaddr: 127.0.0.1
    port: '5005'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_formatter.base()
    len_tag_key: length_tag_key
  states: {}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: pld_enc
    itype: byte
    otype: byte
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {}
- name: pld_enc
  id: parameter
  parameters:
    value: fec.dummy_encoder.make(8000)
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: cent_freq
    dev_args: '""'
    gain0: '80'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Time Domain
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Time Domain
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tag_gate_0, '0', blocks_file_sink_0, '0']
- [blocks_tag_gate_0, '0', uhd_usrp_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [blocks_udp_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_packet_headergenerator_bb_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [digital_packet_headergenerator_bb_0, '0', fec_generic_encoder_0, '0']
- [fec_generic_encoder_0, '0', header_bits, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
